# Repository mattybrad/polymod3

File readme.md:

# PolyMod 3
#### Polyphonic modular synth for Bela and other platforms
More details to come soon. Started a new project after discovering the Bela platform.

## KiCad design pcb/p3mini/p3mini.kicad_pcb

Parts:
C1: 100nF; R_0805_2012Metric
D1, D2, D3, D4, D5, D6, D7, D8: LED; LED_D5.0mm
D9: 1N4148; D_SOD-123
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1, J2: Conn_02x12_Odd_Even; PinSocket_2x12_P2.54mm_Vertical
J3: DIN-5_180degree; MIDI_DIN5
J4: Conn_01x10; PinSocket_1x10_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R58: 10k; R_0805_2012Metric
R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48: 47k; R_0805_2012Metric
R49, R50, R51, R52, R53, R54, R55, R56, R57: 220; R_1206_3216Metric
R59: 470; R_0805_2012Metric
RV1, RV2, RV3, RV4, RV5, RV6, RV7, RV8, RV9, RV10, RV11, RV12, RV13, RV14, RV15, RV16: R_POT; Potentiometer_Alps_RK09K_Single_Vertical
U1, U2, U3, U7: 74HC595; SOIC-16_3.9x9.9mm_P1.27mm
U4, U5, U6: 74HC165; SOIC-16_3.9x9.9mm_P1.27mm
U8: Teensy4.1; Teensy41
U9: 6N138; SSO-8_6.7x9.8mm_P2.54mm_Clearance8mm
U10, U11: 4051; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
/ANA_CHAN0: U8.16 (24_A10_TX6_SCL2), U10.11 (A), U11.11 (A)
/ANA_CHAN1: U8.17 (25_A11_RX6_SDA2), U10.10 (B), U11.10 (B)
/ANA_CHAN2: U8.18 (26_A12_MOSI1), U10.9 (C), U11.9 (C)
/ANA_DATA0: U8.19 (27_A13_SCK1), U10.3 (X)
/ANA_DATA1: U8.20 (28_RX7), U11.3 (X)
/INPUT0: J2.1, R25.1, U4.11 (D0)
/INPUT1: J2.3, R26.1, U4.12 (D1)
/INPUT2: J2.5, R27.1, U4.13 (D2)
/INPUT3: J2.7, R28.1, U4.14 (D3)
/INPUT4: J2.9, R29.1, U4.3 (D4)
/INPUT5: J2.11, R30.1, U4.4 (D5)
/INPUT6: J2.13, R31.1, U4.5 (D6)
/INPUT7: J2.15, R32.1, U4.6 (D7)
/INPUT8: J2.17, R33.1, U5.11 (D0)
/INPUT9: J2.19, R34.1, U5.12 (D1)
/INPUT10: J2.21, R35.1, U5.13 (D2)
/INPUT11: J2.23, R36.1, U5.14 (D3)
/INPUT12: J2.24, R37.1, U5.3 (D4)
/INPUT13: J2.22, R38.1, U5.4 (D5)
/INPUT14: J2.20, R39.1, U5.5 (D6)
/INPUT15: J2.18, R40.1, U5.6 (D7)
/INPUT16: J2.16, R41.1, U6.11 (D0)
/INPUT17: J2.14, R42.1, U6.12 (D1)
/INPUT18: J2.12, R43.1, U6.13 (D2)
/INPUT19: J2.10, R44.1, U6.14 (D3)
/INPUT20: J2.8, R45.1, U6.3 (D4)
/INPUT21: J2.6, R46.1, U6.4 (D5)
/INPUT22: J2.4, R47.1, U6.5 (D6)
/INPUT23: J2.2, R48.1, U6.6 (D7)
/IN_CLOCK: U4.2 (CP), U5.2 (CP), U6.2 (CP), U8.7 (5_IN2)
/IN_CLOCK_ENABLE: U4.15 (~CE), U5.15 (~CE), U6.15 (~CE), U8.8 (6_OUT1D)
/IN_DATA: U4.10 (DS), U8.6 (4_BCLK2)
/IN_LOAD: U4.1 (~PL), U5.1 (~PL), U6.1 (~PL), U8.11 (9_OUT1C)
/LED_CLOCK: U7.11 (SRCLK), U8.37 (15_A1_RX3_SPDIF_IN)
/LED_DATA: U7.14 (SER), U8.38 (16_A2_RX4_SCL1)
/LED_LATCH: U7.12 (RCLK), U8.36 (14_A0_TX3_SPDIF_OUT)
/MIDI_IN: R59.2, U8.2 (0_RX1_CRX2_CS1), U9.6 (VO2)
/OUTPUT0: J1.1, R1.1
/OUTPUT1: J1.3, R2.1
/OUTPUT2: J1.5, R3.1
/OUTPUT3: J1.7, R4.1
/OUTPUT4: J1.9, R5.1
/OUTPUT5: J1.11, R6.1
/OUTPUT6: J1.13, R7.1
/OUTPUT7: J1.15, R8.1
/OUTPUT8: J1.17, R9.1
/OUTPUT9: J1.19, R10.1
/OUTPUT10: J1.21, R11.1
/OUTPUT11: J1.23, R12.1
/OUTPUT12: J1.24, R13.1
/OUTPUT13: J1.22, R14.1
/OUTPUT14: J1.20, R15.1
/OUTPUT15: J1.18, R16.1
/OUTPUT16: J1.16, R17.1
/OUTPUT17: J1.14, R18.1
/OUTPUT18: J1.12, R19.1
/OUTPUT19: J1.10, R20.1
/OUTPUT20: J1.8, R21.1
/OUTPUT21: J1.6, R22.1
/OUTPUT22: J1.4, R23.1
/OUTPUT23: J1.2, R24.1
/OUT_CLOCK: U1.11 (SRCLK), U2.11 (SRCLK), U3.11 (SRCLK), U8.4 (2_OUT2)
/OUT_DATA: U1.14 (SER), U8.3 (1_TX1_CTX2_MISO1)
/OUT_LATCH: U1.12 (RCLK), U2.12 (RCLK), U3.12 (RCLK), U8.5 (3_LRCLK2)
/POT0: RV1.2, U10.13 (X0)
/POT1: RV2.2, U10.14 (X1)
/POT2: RV3.2, U10.15 (X2)
/POT3: RV4.2, U10.12 (X3)
/POT4: RV5.2, U10.1 (X4)
/POT5: RV6.2, U10.5 (X5)
/POT6: RV7.2, U10.2 (X6)
/POT7: RV8.2, U10.4 (X7)
/POT8: RV9.2, U11.13 (X0)
/POT9: RV10.2, U11.14 (X1)
/POT10: RV11.2, U11.15 (X2)
/POT11: RV12.2, U11.12 (X3)
/POT12: RV13.2, U11.1 (X4)
/POT13: RV14.2, U11.5 (X5)
/POT14: RV15.2, U11.2 (X6)
/POT15: RV16.2, U11.4 (X7)
GND: C1.2, J4.1, R25.2, R26.2, R27.2, R28.2, R29.2, R30.2, R31.2, R32.2, R33.2, R34.2, R35.2, R36.2, R37.2, R38.2, R39.2, R40.2, R41.2, R42.2, R43.2, R44.2, R45.2, R46.2, R47.2, R48.2, R58.1, RV1.3, RV2.3, RV3.3, RV4.3, RV5.3, RV6.3, RV7.3, RV8.3, RV9.3, RV10.3, RV11.3, RV12.3, RV13.3, RV14.3, RV15.3, RV16.3, U1.8 (GND), U1.13 (~OE), U2.8 (GND), U2.13 (~OE), U3.8 (GND), U3.13 (~OE), U4.8 (GND), U5.8 (GND), U6.8 (GND), U7.8 (GND), U7.13 (~OE), U8.1 (GND), U8.34 (GND), U8.47 (GND), U9.5 (GND), U10.6 (Inh), U10.7 (VEE), U10.8 (VSS), U11.6 (Inh), U11.7 (VEE), U11.8 (VSS)
unnamed: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K)
unnamed: D1.2 (A), R49.1
unnamed: D2.2 (A), R50.1
unnamed: D3.2 (A), R51.1
unnamed: D4.2 (A), R52.1
unnamed: D5.2 (A), R53.1
unnamed: D6.2 (A), R54.1
unnamed: D7.2 (A), R55.1
unnamed: D8.2 (A), R56.1
unnamed: D9.1 (K), R57.1, U9.2 (C1)
unnamed: D9.2 (A), J3.5, U9.3 (C2)
unnamed: J3.4, R57.2
unnamed: J4.2, U8.33 (41_A17)
unnamed: J4.3, U8.32 (40_A16)
unnamed: J4.4, U8.31 (39_MISO1_OUT1A)
unnamed: J4.5, U8.30 (38_CS1_IN1)
unnamed: J4.6, U8.29 (37_CS)
unnamed: J4.7, U8.28 (36_CS)
unnamed: J4.8, U8.27 (35_TX8)
unnamed: J4.9, U8.26 (34_RX8)
unnamed: J4.10, U8.25 (33_MCLK2)
unnamed: R1.2, U1.15 (QA)
unnamed: R2.2, U1.1 (QB)
unnamed: R3.2, U1.2 (QC)
unnamed: R4.2, U1.3 (QD)
unnamed: R5.2, U1.4 (QE)
unnamed: R6.2, U1.5 (QF)
unnamed: R7.2, U1.6 (QG)
unnamed: R8.2, U1.7 (QH)
unnamed: R9.2, U2.15 (QA)
unnamed: R10.2, U2.1 (QB)
unnamed: R11.2, U2.2 (QC)
unnamed: R12.2, U2.3 (QD)
unnamed: R13.2, U2.4 (QE)
unnamed: R14.2, U2.5 (QF)
unnamed: R15.2, U2.6 (QG)
unnamed: R16.2, U2.7 (QH)
unnamed: R17.2, U3.15 (QA)
unnamed: R18.2, U3.1 (QB)
unnamed: R19.2, U3.2 (QC)
unnamed: R20.2, U3.3 (QD)
unnamed: R21.2, U3.4 (QE)
unnamed: R22.2, U3.5 (QF)
unnamed: R23.2, U3.6 (QG)
unnamed: R24.2, U3.7 (QH)
unnamed: R49.2, U7.15 (QA)
unnamed: R50.2, U7.1 (QB)
unnamed: R51.2, U7.2 (QC)
unnamed: R52.2, U7.3 (QD)
unnamed: R53.2, U7.4 (QE)
unnamed: R54.2, U7.5 (QF)
unnamed: R55.2, U7.6 (QG)
unnamed: R56.2, U7.7 (QH)
unnamed: R58.2, U9.7 (VO1)
unnamed: U1.9 (QH'), U2.14 (SER)
unnamed: U2.9 (QH'), U3.14 (SER)
unnamed: U4.9 (Q7), U5.10 (DS)
unnamed: U5.9 (Q7), U6.10 (DS)
VCC: C1.1, R59.1, RV1.1, RV2.1, RV3.1, RV4.1, RV5.1, RV6.1, RV7.1, RV8.1, RV9.1, RV10.1, RV11.1, RV12.1, RV13.1, RV14.1, RV15.1, RV16.1, U1.10 (~SRCLR), U1.16 (VCC), U2.10 (~SRCLR), U2.16 (VCC), U3.10 (~SRCLR), U3.16 (VCC), U4.16 (VCC), U5.16 (VCC), U6.16 (VCC), U7.10 (~SRCLR), U7.16 (VCC), U8.15 (3V3), U9.8 (VCC), U10.16 (VDD), U11.16 (VDD)

Notes on the sheet:
Output ports
Input ports
Potentiometers
LEDs

Board: 2 copper layers, 104 parts (74 on the bottom side), 140 nets, no tracks yet.

## KiCad design pcb/p3module/p3module.kicad_pcb

Parts:
D1, D2, D3, D4: LED; LED_D5.0mm
H1, H2: MountingHole; MountingHole_3.2mm_M3
J1, J3: Conn_01x08_Female; PinSocket_1x08_P2.54mm_Vertical
J2: Conn_02x10_Odd_Even; PinHeader_1x20_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8: 10k; R_1206_3216Metric
R9, R10, R11, R12, R13, R14, R15, R16: 47k; R_1206_3216Metric
R17, R18, R19, R20: 220; R_1206_3216Metric
RV1, RV2, RV3, RV4: R_POT; Potentiometer_Alps_RK09K_Single_Vertical
U1, U3: 74HC595; SOIC-16_3.9x9.9mm_P1.27mm
U2: 74HC165; SOIC-16_3.9x9.9mm_P1.27mm
U4: 4051; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
/ANA_CHAN0: J2.12, U4.11 (A)
/ANA_CHAN1: J2.10, U4.10 (B)
/ANA_CHAN2: J2.8, U4.9 (C)
/ANA_OUT: J2.6, U4.3 (X)
/IN_CLOCK: J2.13, U2.2 (CP)
/IN_CLOCK_ENABLE: J2.15, U2.15 (~CE)
/IN_DATA_IN: J2.17, U2.9 (Q7)
/IN_DATA_OUT: J2.9, U2.10 (DS)
/IN_LOAD: J2.11, U2.1 (~PL)
/LED_CLOCK: J2.18, U3.11 (SRCLK)
/LED_DATA_IN: J2.20, U3.14 (SER)
/LED_DATA_OUT: J2.14, U3.9 (QH')
/LED_LATCH: J2.16, U3.12 (RCLK)
/OUT_CLOCK: J2.3, U1.11 (SRCLK)
/OUT_DATA_IN: J2.1, U1.14 (SER)
/OUT_DATA_OUT: J2.7, U1.9 (QH')
/OUT_LATCH: J2.5, U1.12 (RCLK)
/POT1: RV1.2, U4.13 (X0)
/POT2: RV2.2, U4.14 (X1)
/POT3: RV3.2, U4.15 (X2)
/POT4: RV4.2, U4.12 (X3)
GND: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), J2.19, R9.2, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, RV1.3, RV2.3, RV3.3, RV4.3, U1.8 (GND), U1.13 (~OE), U2.8 (GND), U3.8 (GND), U3.13 (~OE), U4.6 (Inh), U4.7 (VEE), U4.8 (VSS)
unnamed: D1.2 (A), R17.1
unnamed: D2.2 (A), R18.1
unnamed: D3.2 (A), R19.1
unnamed: D4.2 (A), R20.1
unnamed: J1.1, R1.1
unnamed: J1.2, R2.1
unnamed: J1.3, R3.1
unnamed: J1.4, R4.1
unnamed: J1.5, R5.1
unnamed: J1.6, R6.1
unnamed: J1.7, R7.1
unnamed: J1.8, R8.1
unnamed: J3.1, R9.1, U2.11 (D0)
unnamed: J3.2, R10.1, U2.12 (D1)
unnamed: J3.3, R11.1, U2.13 (D2)
unnamed: J3.4, R12.1, U2.14 (D3)
unnamed: J3.5, R13.1, U2.3 (D4)
unnamed: J3.6, R14.1, U2.4 (D5)
unnamed: J3.7, R15.1, U2.5 (D6)
unnamed: J3.8, R16.1, U2.6 (D7)
unnamed: R1.2, U1.15 (QA)
unnamed: R2.2, U1.1 (QB)
unnamed: R3.2, U1.2 (QC)
unnamed: R4.2, U1.3 (QD)
unnamed: R5.2, U1.4 (QE)
unnamed: R6.2, U1.5 (QF)
unnamed: R7.2, U1.6 (QG)
unnamed: R8.2, U1.7 (QH)
unnamed: R17.2, U3.15 (QA)
unnamed: R18.2, U3.1 (QB)
unnamed: R19.2, U3.2 (QC)
unnamed: R20.2, U3.3 (QD)
VCC: J2.2, RV1.1, RV2.1, RV3.1, RV4.1, U1.10 (~SRCLR), U1.16 (VCC), U2.16 (VCC), U3.10 (~SRCLR), U3.16 (VCC), U4.16 (VDD)

Notes on the sheet:
Output ports
Input ports
Potentiometers
LEDs

Board: 2 copper layers, 30.0 x 100.0 mm, 37 parts (25 on the bottom side), 55 nets.

## KiCad design pcb/polymod3/polymod3.kicad_pcb

Board: 2 copper layers, 250.0 x 110.0 mm, 42 parts (22 on the bottom side), 55 nets.

Parts:
D1, D2, D3, D4: LED; LED_D5.0mm
H1, H2, H3, H4, H5, H6: MountingHole; MountingHole_3.2mm_M3
J2, J3: Conn_01x08_Female; PinHeader_1x08_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R9, R10, R11, R12, R13, R14, R15, R16: 47k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R17, R18, R19, R20: 680; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV1, RV2, RV3, RV4: R_POT; Potentiometer_Alps_RK09K_Single_Vertical
U1: Teensy4.1; Teensy41
U2, U3: 74HC595; DIP-16_W7.62mm_Socket
U4: 74HC165; DIP-16_W7.62mm_Socket
U5, U6: 4051; DIP-16_W7.62mm_Socket

Connections:
/ANA_MAIN: U1.14, U6.3
/ANA_MAIN_CHAN0: U1.5, U6.11
/ANA_MAIN_CHAN1: U1.6, U6.10
/ANA_MAIN_CHAN2: U1.7, U6.9
/Module1/ANA_OUT: U5.3, U6.13
/Module1/IN_DATA_OUT: U1.13, U4.10
/Module1/OUT_DATA_IN: U1.44, U3.14
/Module1/POT1: RV1.2, U5.13
/Module1/POT2: RV2.2, U5.14
/Module1/POT3: RV3.2, U5.15
/Module1/POT4: RV4.2, U5.12
ANA_CHAN0: U1.2, U5.11
ANA_CHAN1: U1.3, U5.10
ANA_CHAN2: U1.4, U5.9
GND: D1.1, D2.1, D3.1, D4.1, R9.2, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, RV1.3, RV2.3, RV3.3, RV4.3, U1.1, U1.34, U1.47, U2.8, U2.13, U3.8, U3.13, U4.8, U5.6, U5.7, U5.8, U6.6, U6.7, U6.8
IN_CLOCK: U1.12, U4.2
IN_CLOCK_ENABLE: U1.11, U4.15
IN_LOAD: U1.10, U4.1
LED_CLOCK: U1.8, U2.11
LED_LATCH: U1.9, U2.12
unnamed: D1.2, R17.1
unnamed: D2.2, R18.1
unnamed: D3.2, R19.1
unnamed: D4.2, R20.1
unnamed: J2.1, R1.1
unnamed: J2.2, R2.1
unnamed: J2.3, R3.1
unnamed: J2.4, R4.1
unnamed: J2.5, R5.1
unnamed: J2.6, R6.1
unnamed: J2.7, R7.1
unnamed: J2.8, R8.1
unnamed: J3.1, R9.1, U4.11
unnamed: J3.2, R10.1, U4.12
unnamed: J3.3, R11.1, U4.13
unnamed: J3.4, R12.1, U4.14
unnamed: J3.5, R13.1, U4.3
unnamed: J3.6, R14.1, U4.4
unnamed: J3.7, R15.1, U4.5
unnamed: J3.8, R16.1, U4.6
unnamed: R1.2, U3.15
unnamed: R2.2, U3.1
unnamed: R3.2, U3.2
unnamed: R4.2, U3.3
unnamed: R5.2, U3.4
unnamed: R6.2, U3.5
unnamed: R7.2, U3.6
unnamed: R8.2, U3.7
unnamed: R17.2, U2.15
unnamed: R18.2, U2.1
unnamed: R19.2, U2.2
unnamed: R20.2, U2.3
OUT_CLOCK: U1.38, U3.11
OUT_LATCH: U1.39, U3.12
VCC: RV1.1, RV2.1, RV3.1, RV4.1, U1.15, U2.10, U2.16, U3.10, U3.16, U4.16, U5.16, U6.16

## Code that names these connections

File experiments/polymodteensy/polymodteensy.ino:

#include <Audio.h>
#include <Wire.h>
#include <SPI.h>
#include <SD.h>
#include <SerialFlash.h>
#include <MIDI.h>

MIDI_CREATE_INSTANCE(HardwareSerial, Serial1, MIDI);

AudioControlSGTL5000     sgtl5000_1;

#include "ModuleSine.h"
#include "ModuleVCO.h"
#include "ModuleMain.h"
#include "SocketConnection.h"
#include "Globals.h"

const byte OUT_LATCH_PIN = 17;
const byte OUT_CLOCK_PIN = 16;
const byte OUT_DATA_PIN = 22;
const byte IN_LOAD_PIN = 8;
const byte IN_CLOCK_ENABLE_PIN = 9;
const byte IN_CLOCK_PIN = 10;
const byte IN_DATA_PIN = 11;
const byte MUX_ADDRESS_PINS[3] = {12,13,14};
const byte MUX_DATA_PIN = 15;
const byte NUM_SHIFT_REGISTERS = 2; // number of each type of shift register
const byte NUM_CHANNELS = 8 * NUM_SHIFT_REGISTERS;

ModuleSine moduleSine;
ModuleVCO moduleVCO;
ModuleMain moduleMain;
SocketConnection connections[MAX_CONNECTIONS];
byte connectionIndex = 0;

byte inputReadings[NUM_CHANNELS];
byte previousInputReadings[NUM_CHANNELS];
SocketOutput *socketOutputs[NUM_CHANNELS];
SocketInput *socketInputs[NUM_CHANNELS];
byte socketInputConnections[NUM_CHANNELS];

void setup() {
  AudioMemory(50);
  sgtl5000_1.enable();
  sgtl5000_1.volume(0.3);

  for(byte i=0; i<NUM_CHANNELS; i++) {
    socketOutputs[i] = NULL;
    socketInputs[i] = NULL;
    socketInputConnections[i] = 255;
  }
  socketOutputs[1] = &moduleSine.audioOut;
  socketOutputs[2] = &moduleVCO.audioOut;
  socketInputs[1] = &moduleVCO.freqModIn;
  socketInputs[2] = &moduleMain.audioIn;

  pinMode(OUT_LATCH_PIN, OUTPUT);
  pinMode(OUT_CLOCK_PIN, OUTPUT);
  pinMode(OUT_DATA_PIN, OUTPUT);
  pinMode(IN_LOAD_PIN, OUTPUT);
  pinMode(IN_CLOCK_ENABLE_PIN, OUTPUT);
  pinMode(IN_CLOCK_PIN, OUTPUT);
  pinMode(IN_DATA_PIN, INPUT);
  for(byte i=0; i<3; i++) {
    pinMode(MUX_ADDRESS_PINS[i], OUTPUT);
  }

  Serial.begin(9600);
  MIDI.begin(MIDI_CHANNEL_OMNI);
}

bool firstLoop = true;
byte loopsWithDifference = 0;
void loop() {
  moduleVCO.update();

  int note, velocity, channel, d1, d2;
  if (MIDI.read()) {
    byte type = MIDI.getType();
    switch (type) {
      case midi::NoteOn:
        note = MIDI.getData1();
        velocity = MIDI.getData2();
        channel = MIDI.getChannel();
        if (velocity > 0) {
          Serial.println(String("Note On:  ch=") + channel + ", note=" + note + ", velocity=" + velocity);
        } else {
          Serial.println(String("Note Off: ch=") + channel + ", note=" + note);
        }
        break;
      case midi::NoteOff:
        note = MIDI.getData1();
        velocity = MIDI.getData2();
        channel = MIDI.getChannel();
        Serial.println(String("Note Off: ch=") + channel + ", note=" + note + ", velocity=" + velocity);
        break;
      default:
        d1 = MIDI.getData1();
        d2 = MIDI.getData2();
        Serial.println(String("Message, type=") + type + ", data = " + d1 + " " + d2);
    }
  }

  byte b,m,c,n;
  for(n=0; n<NUM_CHANNELS; n++) {
    inputReadings[n] = B00000000;
    if(firstLoop) previousInputReadings[n] = B11111111;
  }

  for(b=0; b<8; b++) {
    // for each bit (sent/received serially)

    digitalWrite(OUT_LATCH_PIN, LOW);
    for(m=0; m<NUM_SHIFT_REGISTERS; m++) {
      // for each output multiplexer in the daisy chain
      byte multiplexerNum = NUM_SHIFT_REGISTERS - m - 1; // last multiplexer is first
      byte byteToSend = B00000000;
      for(c=0; c<8; c++) {
        bool bitVal = bitRead(8*multiplexerNum + c + 1, b);
        bitWrite(byteToSend, c, bitVal);
      }
      shiftOut(OUT_DATA_PIN, OUT_CLOCK_PIN, MSBFIRST, byteToSend);
    }
    digitalWrite(OUT_LATCH_PIN, HIGH);

    delayMicroseconds(5); // maybe not needed

    digitalWrite(IN_CLOCK_ENABLE_PIN, HIGH);
    digitalWrite(IN_LOAD_PIN, LOW);
    delayMicroseconds(5);
    digitalWrite(IN_LOAD_PIN, HIGH);
    delayMicroseconds(5);
    digitalWrite(IN_CLOCK_ENABLE_PIN, LOW);

    for(m=0; m<NUM_SHIFT_REGISTERS; m++) {
      for(c=0; c<8; c++) {
        bool bitVal = digitalRead(IN_DATA_PIN);
        byte inputReadingNum = 8*m + 7 - c;
        bitWrite(inputReadings[inputReadingNum], b, bitVal);
        digitalWrite(IN_CLOCK_PIN, HIGH);
        delayMicroseconds(5);
        digitalWrite(IN_CLOCK_PIN, LOW);
      }
    }
  }
  for(n=0; n<NUM_CHANNELS; n++) {
    inputReadings[n] -= 1;
    if(inputReadings[n] != previousInputReadings[n] && !firstLoop) {
      loopsWithDifference ++;
      if(loopsWithDifference == 5) {
        loopsWithDifference = 0;
        if(previousInputReadings[n]!=255) {
          Serial.print("disconnected output ");
          Serial.print(previousInputReadings[n]);
          Serial.print(" from input ");
          Serial.println(n);
          if(socketOutputs[previousInputReadings[n]]!=NULL && socketInputs[n]!=NULL) {
            connections[socketInputConnections[n]].disconnect(); // should also check if this is a valid connection to disconnect
          } else {
            Serial.println("INVALID DISCONNECTION");
          }
        }
        if(inputReadings[n]!=255) {
          Serial.print("connected output ");
          Serial.print(inputReadings[n]);
          Serial.print(" to input ");
          Serial.println(n);
          if(socketOutputs[inputReadings[n]]!=NULL && socketInputs[n]!=NULL) {
            connections[connectionIndex].connect(*socketOutputs[inputReadings[n]], *socketInputs[n]);
            socketInputConnections[n] = connectionIndex;
            connectionIndex ++;
            if(connectionIndex == MAX_CONNECTIONS) connectionIndex = 0;
          } else {
            Serial.println("INVALID CONNECTION");
          }
        }
        previousInputReadings[n] = inputReadings[n];
      }
    }
  }
  delayMicroseconds(10); // just to keep things nice
  firstLoop = false;
}

/*void calculatePolyStatuses() {
  int checkNum = 0; // number of times the whole tree has been checked(?)
  resetSocket(moduleMain.audioIn);
  while(checkNum < 2) {
    checkSocket(moduleMain.audioIn);
    checkNum ++;
  }
}

void checkSocket(Socket &s) {
  bool prevConfirmed = s.confirmed;
  s.checkNum ++;
  if(s.hardcodedPoly) {
    s.poly = true;
    s.confirmed = true;
  }
  bool allMono = true;
  bool allInputsConfirmed = true;
  for(byte i=0; i<MAX_MODULE_INPUTS; i++) {
    if(s.inputs[i].checkNum == checkNum) checkSocket(s); // also should check here that input[i] != socket, but not sure how to do that in C++ yet
    if(s.inputs[i].poly) allMono = false;
    if(!s.inputs[i].confirmed) allInputsConfirmed = false;
  }
  if(!allMono) {
    s.poly = true;
    s.confirmed = true;
  }
  if(allInputsConfirmed) {
    s.confirmed = true;
  }
  if(!prevConfirmed && s.confirmed) {
    s.updatePolyRouting();
  }
}

void resetSocket(Socket &s) {
  s.checkNum = 0;
  s.poly = false;
  s.confirmed = false;
  for(byte i=0; i<MAX_MODULE_INPUTS; i++) {
    if(s.inputs[i].confirmed) resetSocket(s.inputs[i]);
  }
}*/

## Commit log

2020-11-16 basic midi implementation working
2020-11-16 readme was in the wrong folder
2020-11-16 envelope and filter working with decent performance
2020-11-16 experimentation
2020-11-17 benchmark patch working, about to refactor code
2020-11-17 it compiles but doesn't actually do anything
2020-11-17 looking good so far
2020-11-17 it makes a sound!
2020-11-17 new modules, much boilerplate
2020-11-17 kinda working, bit tired, fix later
2020-11-18 updated log
2021-01-25 ignore this
2021-01-25 now trying the teensy for more power
2021-01-25 moving back to the shed
2021-01-25 patching working really nicely
2021-01-26 working through the boring but important stuff
2021-01-26 polyphonic sine wave works!
2021-01-26 physical patching causes audio patching - nice
2021-01-26 disconnections also now kinda working
2021-01-26 analog controls kinda working
2021-01-26 here comes MIDI
2021-01-26 started messing with kicad
2021-01-27 mixing mod signals
2021-01-27 first steps toward poly tree checking
2021-02-08 kicad stuff
2021-02-08 pcb layout (early)
2021-02-10 still playing in kicad
2021-02-10 nice
2021-02-10 routing...
2021-02-12 about to change the design again...
2021-02-12 teensy pin thoughts
2021-02-12 new modular design
2021-02-12 reduced width to 6HP
2021-02-12 reduced height to 10cm
2021-02-12 routing is hard
2021-02-14 another attempt at routing
2021-02-14 slightly better routing
2021-02-15 routing worked but one of the sockets was on the wrong side. ugh
2021-02-15 better routing
2021-02-15 done for the day
2021-02-16 making gerbers
2021-02-16 fixed bom etc
2021-02-16 so much kicad
2021-02-16 polymod mini looks good so far
2021-02-16 mini schematic nearly done
2021-02-19 mini pcb layout started
2021-02-23 layout
